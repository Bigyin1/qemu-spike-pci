## pcidev/patches/kconfig.patch
```kconfig
config SPIKE_PCI
    bool
    default y if TEST_DEVICES
    depends on PCI && MSI_NONBROKEN
```
